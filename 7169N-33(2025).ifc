Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: c60523fd-3f0e-49af-90d8-b84c368db3f6, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 7169N-33(2025).ifc
Time: 2025-12-16T17:40:27+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_9765_1
InPort_9765_3

# IfcFlowController: 7169N-33(2025):7169N-33 Shower faucet with shower set, 7169N-33(2025):7169N-33 Shower faucet with shower set:9765
In: Level 1
Type - PredefinedType: FAUCET; Material: Matt black
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7169N-33(2025); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7169N-33; Name: 7169N-33 Shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 33 mm
Type - Dimensions - FaucetNominalDepth: 87 mm; FaucetNominalHeight: 100.184 mm; FaucetNominalWidth: 342.373 mm; HandShowerNominalDepth: 124.45 mm; HandShowerNominalHeight: 765.13 mm; HandShowerNominalWidth: 236.108 mm
Type - General - Author: BIMStone; BIMObjectName: 7169N-33(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 2025/10/01
Type - Green Building Properties - EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; LVI Number: 6310961; Noise Class 02ls: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7169N-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7169N-33
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/7169N-33; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/7169N-33; FDV Document URL: http://www.oras.com/datasheet/7169N-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7169N-33; Group: ShowerFaucetsWithShowerSet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7169N-33; Long Marketing: Designed to impress and give an elegant solution for any bathroom. This thermostat gives you a most comfortable and enjoyable shower experience every day. With focus on high performance while still have and eye on the aesthetics and details to secure an elegant installation.The handles are designed to be elegant while still providing a good grip for easy.Our new developed magnectic shelf ”MagShelf” completes the design while covering the connection to the wall.Elegant Handshower designed to fit in every bathroom.Our 3-spray handshower is easy to operate with a nice designed push button to easily change the water sprays.The hand shower slider is designed for an easy grib and easy adjustment in height with just one hand.Elegant design and total enjoyment; Manufacturer: Oras; Market: Denmark;Estonia;Finland;International;Lithuania;Latvia;Norway;Sweden; Mobile Product Information URL: http://mpi.oras.com/7169N-33; Model: 7169N-33 Shower faucet with shower set; Name_en: 7169N-33 Shower faucet with shower set; OmniClass Number: 23.31.17.00; OmniClass Title: Showers; Product Code: 7169N-33; Product Family: Oras Optima Style; Product Image URL: http://static.oras.com/image/7169N-33; Product URL: http://static.oras.com/7169N-33; Technical DataSheet URL: http://www.oras.com/datasheet/7169N-33/en; Type Name: 7169N-33 Shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Matt black
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Anti-twist hose connector; Backflow Prevention EN1717: EB; Connection: Straight coupling(s);Direct connection;Cover plate(s); Connection Size: G3/4; Eco Flow At 300kPa: 0.12 dm3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.22 dm3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Installation Width: 150 ± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: Hand shower;MagShelf. Removable shelf with magnetic attachment;Adjustable shower rail bracket;Shower hose (1750 mm);Shower rail;Anti limescale technology (easy to clean);Soap dish;Twist guard for shower hose;Variable fixing points; Shower Spray: Normal - Even and soft water stream;Massage - Strong water stream due to rotatable spray nozzles;Rain - Even and strong water stream; Shower Spray Number: 3 spray functions; Surface treatment: Matt black; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Pset_ElementShading - Color: Matt black
Type - Pset_ManufacturerTypeInformation - ModelReference: 7169N-33; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 7169N-33 Shower faucet with shower set
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Matt black
Pset_DistributionFlowElementCommon - Reference: 7169N-33 Shower faucet with shower set; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7169N-33(2025); Family and Type: 7169N-33(2025): 7169N-33 Shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7169N-33 Shower faucet with shower set; Type Id: 9745; WarrantyStartDate: n/a
Constraints - Elevation from Level: 0 mm; FaucetDefaultElevation: 900.078 mm; HandShowerDefaultElevation: 1000 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.52482 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; DistanceX-axis: 200 mm; DistanceY-axis: 200 mm; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.026627 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
